<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\StatusPanel.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>ALL</name>
      <member>
        <project>StatusPanel</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>StatusPanel</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>StatusPanel</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>StatusPanel</project>
        <configuration>RouterZLight</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


